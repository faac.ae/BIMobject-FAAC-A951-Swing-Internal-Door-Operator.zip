Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-12-11T12:38:04
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcDiscreteAccessory: NBS_FAACEntranceSolutionsUK_CtrldDrClsrs_A951AutomaticSwingDoorOperator:ArticulatedArmLH, NBS_FAACEntranceSolutionsUK_CtrldDrClsrs_A951AutomaticSwingDoorOperator:ArticulatedArmLH:311874
In: Level 0
Type - Material: NBS_FAAC_Aluminium (7)
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_30_36_59_15:Controlled door closers; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Compact automation for swing doors.; DurationUnit: year; ExpectedLife: Ten year; Features: n/a; Finish: Anodized; Grade: n/a; Manufacturer: architect.esuk@faactechnologies.com; Material: Aluminium; ModelNumber: n/a; ModelReference: A951 Automatic Swing Door Operator; Name: ControlledDoorClosers_A951AutomaticSwingDoorOperator_ArticulatedArmLH_FAACEntranceSolutionsUK; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: One year; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_FAACEntranceSolutionsUK_ControlledDoorClosers_A951AutomaticSwingDoorOperator_ArticulatedArmLH; ManufacturerName: FAAC Entrance Solutions UK; ManufacturerURL: https://www.faacentrancesolutions.co.uk/; ProductInformation: https://source.thenbs.com/product/-/932f1a8a-06de-4c42-926e-ba76f8b19453/81d96097-1587-4a30-b4c3-f1e733d5157e; Uniclass2015Title: Controlled door closers; Uniclass2015Code: Pr_30_36_59_15; Uniclass2015Version: Products v1.36; Version: 1
Type - NBS_Data - Accessories: Not required,Extension shaft; Arm: Articulated arm; ClassificationGradesMinimumCategoryOfUse: 3; CloserFunctions: Controlled closing; CountryOfMaterialOrigin: Italy; CountryOfProductManufacture: Italy; Dimensions: 575 x 60 x 70 mm; Form: Overhead, face-fixed; Frequency: 50/60 Hz; Handing: Left hand; IngressProtectionIPRating: IP 23 (indoor use only); ManufacturingPlantLocation: Via Calari, 10, 40069 Zola Predosa BO, Italy; MaterialsAndFinishesArms: Extruded aluminium; MaterialsAndFinishesBodies: Extruded aluminium; MaterialsAndFinishesCasings: Anodized extruded aluminium; MaterialsAndFinishesColour: Silver; MaximumPowerUsage: 100 W; Mounting: Frame transom mounted,Door mounted,Wall lintel mounted; OpeningSpeed: 4–10 seconds (adjustable); OperatingTemperature: -20°C to +55°C; PowerSupply: 220–240 V; Standard: To EN 16005, EN 61000-6-2, EN 61000-6-3 and EN 13849; Swing: Inward swing,Outward swing; Weight: 7 kg
Type - IFC - IfcExportAs: IfcDiscreteAccessoryType; IfcExportType: USERDEFINED
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
